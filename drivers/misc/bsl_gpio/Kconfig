## drivers/misc/bsl_gpio/Kconfig
```kconfig
config BSL
	tristate "bsl drivers"
	help
	  Say Y here if you want to use bsl drivers
```
